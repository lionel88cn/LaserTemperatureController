# Keil uVision project LaserTmpCtrl.uvproj, settings and files
target STM32L152RB (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LaserTmpCtrl +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: .\;C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Libraries\STM32L1xx_StdPeriph_Driver\inc;C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Utilities\STM32L-DISCOVERY;C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Libraries\STMTouch_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3c00
  memory RVCT10: RAM 0x20003c00 size 0x400
  group Startup
    ./: startup_stm32l1xx_md.s
  group Driver
    C:/STMicroelectronics/STM32L1_Discovery_Firmware_Pack_V1.0.3/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
    C:/STMicroelectronics/STM32L1_Discovery_Firmware_Pack_V1.0.3/Libraries/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32l1xx_sw.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32l1xx.c tsl_touchkey.c
    C:/STMicroelectronics/STM32L1_Discovery_Firmware_Pack_V1.0.3/Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group User
    ./: discover_functions.c main.c stm32l1xx_it.c system_stm32l1xx.c tsl_user.c
